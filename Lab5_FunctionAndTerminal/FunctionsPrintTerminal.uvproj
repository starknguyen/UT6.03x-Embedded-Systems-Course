# Keil uVision project FunctionsPrintTerminal.uvproj, settings and files
target FunctionsPrintTerminal (ARM-ADS)
  device: TM4C123GE6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: FunctionsPrintTerminal
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup_TM4C123.s main.c UART.c UART.h
